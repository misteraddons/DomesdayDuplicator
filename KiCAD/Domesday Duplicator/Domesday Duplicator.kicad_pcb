# Repository misteraddons/DomesdayDuplicator (continued)

## KiCad design Hardware/DomesdayDuplicator-base-DE0Nano/DomesdayDuplicator-base-DE0Nano.kicad_pcb (continued)

Parts:
J301: GPIFII_J6; PinHeader_2x20_P2.54mm_Vertical
J302: GPIFII_J7; PinHeader_2x20_P2.54mm_Vertical

Connections:
+5V: J301.3 (USB3_VBUS), J301.4 (USB3_VBUS); also elsewhere on the board
/Cypress FX3/USB_CTL0: J301.31 (CTL0); also elsewhere on the board
/Cypress FX3/USB_CTL1: J301.29 (CTL1); also elsewhere on the board
/Cypress FX3/USB_CTL2: J301.27 (CTL2); also elsewhere on the board
/Cypress FX3/USB_CTL3: J301.25 (CTL3); also elsewhere on the board
/Cypress FX3/USB_CTL4: J301.23 (CTL4); also elsewhere on the board
/Cypress FX3/USB_CTL5: J301.21 (CTL5); also elsewhere on the board
/Cypress FX3/USB_CTL6: J301.19 (CTL6); also elsewhere on the board
/Cypress FX3/USB_CTL7: J301.17 (CTL7); also elsewhere on the board
/Cypress FX3/USB_CTL8: J301.15 (CTL8); also elsewhere on the board
/Cypress FX3/USB_CTL9: J301.13 (CTL9); also elsewhere on the board
/Cypress FX3/USB_CTL10: J301.11 (CTL10); also elsewhere on the board
/Cypress FX3/USB_CTL11: J301.9 (CTL11); also elsewhere on the board
/Cypress FX3/USB_CTL12: J301.7 (CTL12); also elsewhere on the board
/Cypress FX3/USB_DATA0: J301.38 (DQ0); also elsewhere on the board
/Cypress FX3/USB_DATA1: J301.36 (DQ1); also elsewhere on the board
/Cypress FX3/USB_DATA2: J301.34 (DQ2); also elsewhere on the board
/Cypress FX3/USB_DATA3: J301.32 (DQ3); also elsewhere on the board
/Cypress FX3/USB_DATA4: J301.30 (DQ4); also elsewhere on the board
/Cypress FX3/USB_DATA5: J301.28 (DQ5); also elsewhere on the board
/Cypress FX3/USB_DATA6: J301.26 (DQ6); also elsewhere on the board
/Cypress FX3/USB_DATA7: J301.24 (DQ7); also elsewhere on the board
/Cypress FX3/USB_DATA8: J301.22 (DQ8); also elsewhere on the board
/Cypress FX3/USB_DATA9: J301.20 (DQ9); also elsewhere on the board
/Cypress FX3/USB_DATA10: J301.18 (DQ10); also elsewhere on the board
/Cypress FX3/USB_DATA11: J301.16 (DQ11); also elsewhere on the board
/Cypress FX3/USB_DATA12: J301.14 (DQ12); also elsewhere on the board
/Cypress FX3/USB_DATA13: J301.12 (DQ13); also elsewhere on the board
/Cypress FX3/USB_DATA14: J301.10 (DQ14); also elsewhere on the board
/Cypress FX3/USB_DATA15: J301.8 (DQ15); also elsewhere on the board
/Cypress FX3/USB_DATA16: J302.38 (DQ16); also elsewhere on the board
/Cypress FX3/USB_DATA17: J302.36 (DQ17); also elsewhere on the board
/Cypress FX3/USB_DATA18: J302.34 (DQ18); also elsewhere on the board
/Cypress FX3/USB_DATA19: J302.32 (DQ19); also elsewhere on the board
/Cypress FX3/USB_DATA20: J302.30 (DQ20); also elsewhere on the board
/Cypress FX3/USB_DATA21: J302.28 (DQ21); also elsewhere on the board
/Cypress FX3/USB_DATA22: J302.26 (DQ22); also elsewhere on the board
/Cypress FX3/USB_DATA23: J302.24 (DQ23); also elsewhere on the board
/Cypress FX3/USB_DATA24: J302.22 (DQ24); also elsewhere on the board
/Cypress FX3/USB_DATA25: J302.20 (DQ25); also elsewhere on the board
/Cypress FX3/USB_DATA26: J302.18 (DQ26); also elsewhere on the board
/Cypress FX3/USB_DATA27: J302.16 (DQ27); also elsewhere on the board
/Cypress FX3/USB_DATA28: J302.12 (DQ28); also elsewhere on the board
/Cypress FX3/USB_DATA29: J302.10 (DQ29); also elsewhere on the board
/Cypress FX3/USB_DATA30: J302.8 (DQ30); also elsewhere on the board
/Cypress FX3/USB_DATA31: J302.6 (DQ31); also elsewhere on the board
/Cypress FX3/USB_PCLK: J301.35 (PCLK); also elsewhere on the board
GND: J301.6 (GND), J301.33 (GND), J301.37 (GND), J302.13 (GND), J302.15 (GND), J302.17 (GND), J302.25 (GND), J302.29 (GND), J302.39 (GND), J302.40 (GND); also elsewhere on the board

Parts:
C401, C403, C405, C407: 100nF; C_0805_2012Metric
C402, C404, C406, C408: 2.2uF tant; CP_EIA-3216-18_Kemet-A
J401: MOD0_Connector; IDC-Header_2x10_P2.54mm_Vertical
J402: MOD1_Connector; IDC-Header_2x10_P2.54mm_Vertical
RN401, RN402, RN403, RN404, RN405, RN406, RN407, RN408: 22R; R_Array_Convex_4x1206

Connections:
+3.3VA: C401.1, C402.1, C403.1, C404.1, J401.19, J402.19; also elsewhere on the board
+5VA: C405.1, C406.1, C407.1, C408.1, J401.18, J402.18; also elsewhere on the board
/DE0-Nano/MOD0_CLK: J401.17; also elsewhere on the board
/DE0-Nano/MOD0_D0: RN401.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD0_D1: RN401.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD0_D2: RN401.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD0_D3: RN401.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD0_D4: RN402.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD0_D5: RN402.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD0_D6: RN402.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD0_D7: RN402.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD0_D8: RN403.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD0_D9: RN403.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD0_D10: RN403.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD0_D11: RN403.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD0_D12: RN404.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD0_D13: RN404.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD0_D14: RN404.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD0_D15: RN404.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD1_CLK: J402.17; also elsewhere on the board
/DE0-Nano/MOD1_D0: RN405.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD1_D1: RN405.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD1_D2: RN405.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD1_D3: RN405.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD1_D4: RN406.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD1_D5: RN406.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD1_D6: RN406.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD1_D7: RN406.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD1_D8: RN407.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD1_D9: RN407.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD1_D10: RN407.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD1_D11: RN407.4 (R4.1); also elsewhere on the board
/DE0-Nano/MOD1_D12: RN408.1 (R1.1); also elsewhere on the board
/DE0-Nano/MOD1_D13: RN408.2 (R2.1); also elsewhere on the board
/DE0-Nano/MOD1_D14: RN408.3 (R3.1); also elsewhere on the board
/DE0-Nano/MOD1_D15: RN408.4 (R4.1); also elsewhere on the board
/Module Headers/M0_D0: J401.1, RN401.8 (R1.2)
/Module Headers/M0_D1: J401.2, RN401.7 (R2.2)
/Module Headers/M0_D2: J401.3, RN401.6 (R3.2)
/Module Headers/M0_D3: J401.4, RN401.5 (R4.2)
/Module Headers/M0_D4: J401.5, RN402.8 (R1.2)
/Module Headers/M0_D5: J401.6, RN402.7 (R2.2)
/Module Headers/M0_D6: J401.7, RN402.6 (R3.2)
/Module Headers/M0_D7: J401.8, RN402.5 (R4.2)
/Module Headers/M0_D8: J401.9, RN403.8 (R1.2)
/Module Headers/M0_D9: J401.10, RN403.7 (R2.2)
/Module Headers/M0_D10: J401.11, RN403.6 (R3.2)
/Module Headers/M0_D11: J401.12, RN403.5 (R4.2)
/Module Headers/M0_D12: J401.13, RN404.8 (R1.2)
/Module Headers/M0_D13: J401.14, RN404.7 (R2.2)
/Module Headers/M0_D14: J401.15, RN404.6 (R3.2)
/Module Headers/M0_D15: J401.16, RN404.5 (R4.2)
/Module Headers/M1_D0: J402.1, RN405.8 (R1.2)
/Module Headers/M1_D1: J402.2, RN405.7 (R2.2)
/Module Headers/M1_D2: J402.3, RN405.6 (R3.2)
/Module Headers/M1_D3: J402.4, RN405.5 (R4.2)
/Module Headers/M1_D4: J402.5, RN406.8 (R1.2)
/Module Headers/M1_D5: J402.6, RN406.7 (R2.2)
/Module Headers/M1_D6: J402.7, RN406.6 (R3.2)
/Module Headers/M1_D7: J402.8, RN406.5 (R4.2)
/Module Headers/M1_D8: J402.9, RN407.8 (R1.2)
/Module Headers/M1_D9: J402.10, RN407.7 (R2.2)
/Module Headers/M1_D10: J402.11, RN407.6 (R3.2)
/Module Headers/M1_D11: J402.12, RN407.5 (R4.2)
/Module Headers/M1_D12: J402.13, RN408.8 (R1.2)
/Module Headers/M1_D13: J402.14, RN408.7 (R2.2)
/Module Headers/M1_D14: J402.15, RN408.6 (R3.2)
/Module Headers/M1_D15: J402.16, RN408.5 (R4.2)
GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, J401.20, J402.20; also elsewhere on the board

Parts:
C501, C504: 100nF; C_0805_2012Metric
C502, C503: 10uF tant; CP_EIA-3528-21_Kemet-B
L501: 100uH; L_Bourns_SRN8040TA
U501: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3.3VA: C503.1, C504.1, U501.2 (VO); also elsewhere on the board
+5V: L501.1; also elsewhere on the board
+5VA: C501.1, C502.1, L501.2, U501.3 (VI); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, U501.1 (GND); also elsewhere on the board

Parts:
FID601, FID602, FID603: Fiducial; Fiducial_0.5mm_Dia_1mm_Outer
H601, H602, H604, H605: MountingHole; MountingHole_3.2mm_M3
H603, H606: MountingHole; MountingHole_2.2mm_M2

Notes on the sheet:
Module mounting holes
Board mounting holes

Board: 2 copper layers, 99.1 x 90.8 mm, 38 parts (2 on the bottom side), 116 nets.

## KiCad design Hardware/DomesdayDuplicator-module-ADS825/DomesdayDuplicator-module-ADS825.kicad_pcb

Parts:
C201, C202, C203: 100nF; C_0805_2012Metric
C204: 2.2uF Tant; CP_EIA-3216-18_Kemet-A
C205: 330pF; C_0805_2012Metric
C206: 33pF; C_0805_2012Metric
C207: 470pF; C_0805_2012Metric
C208: 100pF; C_0805_2012Metric
C209: 270pF; C_0805_2012Metric
J201: RF_In_50R; RF_SMA_RightAngle_5-1814400-1
L201: 680uH; L_0805_2012Metric
L202: 560uH; L_0805_2012Metric
R201: 56R; R_0805_2012Metric
R202: 200R; R_0805_2012Metric
R203: 100R; R_0805_2012Metric
R204: 1K5; R_0805_2012Metric
R205: 1K; R_0805_2012Metric
R206: 680R; R_0805_2012Metric
R207: 560R; R_0805_2012Metric
R208, R209: 47R; R_0805_2012Metric
SW201: Gain_Select; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
U201: OPA690IDBVT; SOT-23-6

Connections:
+5VA: C203.2, C204.1, U201.5 (ENABLE), U201.6 (V+); also elsewhere on the board
/ADC/ANALOG_IN: R209.1; also elsewhere on the board
/ADC/DC_OFFSET: C201.1, R203.2; also elsewhere on the board
GND: C202.1, C203.1, C204.2, C205.1, C207.1, C209.1, J201.2 (Ext), R201.2, U201.2 (V-); also elsewhere on the board
unnamed: C201.2, J201.1 (In), R201.1
unnamed: C202.2, R202.1
unnamed: C205.2, C206.2, L201.1, R208.1
unnamed: C206.1, C207.2, C208.2, L201.2, L202.1
unnamed: C208.1, C209.2, L202.2, R209.2
unnamed: R202.2, R204.2, R205.2, R206.2, R207.2, U201.4 (-)
unnamed: R203.1, U201.3 (+)
unnamed: R204.1, SW201.1
unnamed: R205.1, SW201.2
unnamed: R206.1, SW201.3
unnamed: R207.1, SW201.4
unnamed: R208.2, SW201.5, SW201.6, SW201.7, SW201.8, U201.1

Notes on the sheet:
2N Elliptic Filter (14 MHz low-pass)
Filter capactors should be 5% tolerance
Note: The cable terminating resistor should take into account the parallel resistance of the dividing network: 1000 / 2 = 500 Ohms Rtotal = R1 x R2 / (R1 + R2) (500 * 56) / (500 + 56) = 50.36 Ohms

Parts:
C301, C303, C305, C307, C308, C311, C313, C315: 100nF; C_0805_2012Metric
C302, C304, C306, C309, C310, C312, C314, C316: 2.2uF Tant; CP_EIA-3216-18_Kemet-A
R301, R302: 1K; R_0805_2012Metric
U301: MCP602; SOIC-8_3.9x4.9mm_P1.27mm
U302: ADS825E; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: C307.1, C309.1, U302.17 (RSEL), U302.28 (VDRV); also elsewhere on the board
+5VA: C301.1, C302.1, C303.1, C304.1, U301.8 (V+), U302.15 (+Vs), U302.27 (+Vs); also elsewhere on the board
/ADC/ANALOG_IN: U302.25 (IN); also elsewhere on the board
/ADC/CLK: U302.14 (CLK); also elsewhere on the board
/ADC/DC_OFFSET: U301.1, U301.2 (-); also elsewhere on the board
/ADC/DO0: U302.11 (D0); also elsewhere on the board
/ADC/DO1: U302.10 (D1); also elsewhere on the board
/ADC/DO2: U302.9 (D2); also elsewhere on the board
/ADC/DO3: U302.8 (D3); also elsewhere on the board
/ADC/DO4: U302.7 (D4); also elsewhere on the board
/ADC/DO5: U302.6 (D5); also elsewhere on the board
/ADC/DO6: U302.5 (D6); also elsewhere on the board
/ADC/DO7: U302.4 (D7); also elsewhere on the board
/ADC/DO8: U302.3 (D8); also elsewhere on the board
/ADC/DO9: U302.2 (D9); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, U301.4 (V-), U302.1 (GND), U302.12 (~OE), U302.13 (PD), U302.16 (GND), U302.18 (~INT/EXT), U302.26 (AGND); also elsewhere on the board
unnamed: C305.1, C306.1, R301.1, U302.22 (REFT)
unnamed: C308.1, C310.1, R302.1, U302.19 (REFB)
unnamed: C311.1, C312.1, U302.21 (ByT)
unnamed: C313.1, C314.1, U302.20 (ByB)
unnamed: C315.1, C316.1, U302.23 (CM)
unnamed: R301.2, R302.2, U301.3 (+), U301.5 (+)
unnamed: U301.6 (-), U301.7, U302.24 (~IN)

Parts:
C401, C402: 100nF; C_0805_2012Metric
U401, U402: 74LVTH541; SSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3V3: C401.1, C402.1, U401.20 (VCC), U402.20 (VCC); also elsewhere on the board
/ADC/DO0: U401.2 (A0); also elsewhere on the board
/ADC/DO1: U401.3 (A1); also elsewhere on the board
/ADC/DO2: U401.4 (A2); also elsewhere on the board
/ADC/DO3: U401.5 (A3); also elsewhere on the board
/ADC/DO4: U401.6 (A4); also elsewhere on the board
/ADC/DO5: U401.7 (A5); also elsewhere on the board
/ADC/DO6: U401.8 (A6); also elsewhere on the board
/ADC/DO7: U401.9 (A7); also elsewhere on the board
/ADC/DO8: U402.2 (A0); also elsewhere on the board
/ADC/DO9: U402.3 (A1); also elsewhere on the board
/Header/DB0: U401.18 (Y0); also elsewhere on the board
/Header/DB1: U401.17 (Y1); also elsewhere on the board
/Header/DB2: U401.16 (Y2); also elsewhere on the board
/Header/DB3: U401.15 (Y3); also elsewhere on the board
/Header/DB4: U401.14 (Y4); also elsewhere on the board
/Header/DB5: U401.13 (Y5); also elsewhere on the board
/Header/DB6: U401.12 (Y6); also elsewhere on the board
/Header/DB7: U401.11 (Y7); also elsewhere on the board
/Header/DB8: U402.18 (Y0); also elsewhere on the board
/Header/DB9: U402.17 (Y1); also elsewhere on the board
/Header/DB10: U402.16 (Y2); also elsewhere on the board
/Line Drivers/TRIGGER_IN: U402.4 (A2); also elsewhere on the board
GND: C401.2, C402.2, U401.1 (G1), U401.10 (GND), U401.19 (G2), U402.1 (G1), U402.5 (A3), U402.6 (A4), U402.7 (A5), U402.8 (A6), U402.9 (A7), U402.10 (GND), U402.19 (G2); also elsewhere on the board

Parts:
C501: 100nF; C_0805_2012Metric
C502: 2.2uF Tant; CP_EIA-3216-18_Kemet-A
J501: Trigger_In_50R; RF_SMA_RightAngle_5-1814400-1
R501, R502: 47R; R_0805_2012Metric
R503: 10K; R_0805_2012Metric
RV501: 10K; Potentiometer_Bourns_3314G_Vertical
U501: TLV3501; SOT-23-6

Connections:
+5VA: C501.1, C502.1, RV501.1, U501.4 (V+); also elsewhere on the board
/Line Drivers/TRIGGER_IN: R503.2, U501.5; also elsewhere on the board
GND: C501.2, C502.2, J501.2 (Ext), RV501.3, U501.2 (V-), U501.6 (SHDN); also elsewhere on the board
unnamed: J501.1 (In), R501.2
unnamed: R501.1, U501.1 (-)
unnamed: R502.1, RV501.2
unnamed: R502.2, R503.1, U501.3 (+)

Notes on the sheet:
Note: The potentiometer sets the Vref trigger point between +5V and 0V
