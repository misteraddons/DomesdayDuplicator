# Repository misteraddons/DomesdayDuplicator

File README.md:

# Domesday Duplicator

## Synopsis

The Domesday Duplicator is a USB3 based DAQ designed for the high-speed acquisition of analogue RF data.

The Domesday Duplicator was originally designed to allow the backup of Domesday AIV LaserDiscs (as well as generic laserdiscs) through the direct sampling of the RF data from the optical head (laser) of a LaserDisc player.  Since it's inception the project has expanded to include backup of other optical and magnetic media.

The hardware/software solution is designed to act as a sampling front-end to the ld-decode (software decode of laserdiscs) project https://github.com/happycube/ld-decode and can produce raw RF image files ready for software decoding.

Please see http://www.domesday86.com/?page_id=978 for detailed documentation on the Domesday Duplicator and overall information about the Domesday86 project.

There are several components that make up the Domesday Duplicator:

Terasic DE0-Nano FPGA development board - The DE0-Nano is a low-cost FPGA development board containing an Altera Cyclone IV FPGA.  The DE0-Nano is used to process the raw 10-bit ADC data stream and provides FIFO buffering (towards the FX3) and sample conversion from unsigned 10-bit to scaled 16-bit signed data.  The FPGA provides a dual-clock FIFO; receiving ADC data at a maximum of 40 MSPS (million samples per second) and transmitting the data to the FX3 at a maximum of 60 MSPS.  This is to ensure that no data is lost during sustained transfers (as RF sampling of a disc can take more than 40 minutes).

Cypress FX3 SuperSpeed Explorer board - The FX3 is a low-cost USB3 development board from Cypress.  The FX3 is used to buffer data from the FPGA and provide it to a host computer using USB3.  USB3 is required for this application due to the high-data bandwidth necessary for high-speed/high-resolution sampling.

Domesday Duplicator DE0-Nano base - This custom board provides the interface between the DE0-Nano and the Cypress FX3 board and contains 2 'slots' for Domesday Duplicator Modules.  As well as connectivity and databus routing the base board also contains the basic power supply circuitry for the modules.

Domesday Duplicator ADS825 module - A custom ADC board based around the Texas Instruments ADS825 10-Bit, 40MSPS analogue to digital converter. This board contains an RF amplifier and conditioner (to amplify the output from the laserdisc player RF tap and condition it for the single-ended ADC chip) as well as line-buffers to interface the ADC to the databus of the base board.

## Motivation

The Domesday86 project is involved in the documentation and preservation of the BBC Domesday Project from 1986.  The Domesday project provided a set of analogue laserdiscs in a proprietary format (like standard laserdiscs but with some specific extensions only supported by the Philips VP415 laserdisc player).

The Domesday Duplicator is intended to allow high-quality back-ups of the analogue information contained on the laserdiscs by bypassing most of the 30-year-old electronics in the VP415 player.  Direct RF sampling also allows all information on the laserdiscs to be stored (unlike conventional RGB sampling of the video output).  Since AIV laserdiscs are a combination of video, pictures, sound and data (as well as numerous VBI streams), direct RF sampling is the preferred method of preservation.

## Installation

Please see http://www.domesday86.com/?page_id=978 for detailed documentation on the Domesday Duplicator

## Author

Domesday Duplicator is written and maintained by Simon Inns.

## Software License (GPLv3)

    Domesday Duplicator is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    Domesday Duplicator is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with this program.  If not, see <http://www.gnu.org/licenses/>.

## Hardware License (Creative Commons BY-SA 4.0)

Please see the following link for details: https://creativecommons.org/licenses/by-sa/4.0/

You are free to:

Share - copy and redistribute the material in any medium or format
Adapt - remix, transform, and build upon the material
for any purpose, even commercially.

This license is acceptable for Free Cultural Works.

The licensor cannot revoke these freedoms as long as you follow the license terms.

Under the following terms:

Attribution - You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.

ShareAlike - If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.

No additional restrictions - You may not apply legal terms or technological measures that legally restrict others from doing anything the license permits.

## KiCad design KiCAD/Domesday Duplicator/Domesday Duplicator.kicad_pcb

Parts:
J101: DE0-Nano_GPIO1; PinSocket_2x20_P2.54mm_Vertical; LCSC Part C2977589
J102: DE0-Nano_GPIO0; PinSocket_2x20_P2.54mm_Vertical; LCSC Part C2977589

Connections:
+5V: J101.11 (5V_VCC), J102.11 (5V_VCC); also elsewhere on the board
ADC_CLK: J102.40 (GPIO_33); also elsewhere on the board
ADC_DATA0: J102.39 (GPIO_32); also elsewhere on the board
ADC_DATA1: J102.38 (GPIO_31); also elsewhere on the board
ADC_DATA2: J102.37 (GPIO_30); also elsewhere on the board
ADC_DATA3: J102.36 (GPIO_29); also elsewhere on the board
ADC_DATA4: J102.35 (GPIO_28); also elsewhere on the board
ADC_DATA5: J102.34 (GPIO_27); also elsewhere on the board
ADC_DATA6: J102.33 (GPIO_26); also elsewhere on the board
ADC_DATA7: J102.32 (GPIO_25); also elsewhere on the board
ADC_DATA8: J102.31 (GPIO_24); also elsewhere on the board
ADC_DATA9: J102.28 (GPIO_23); also elsewhere on the board
GND: J101.12 (GND), J101.30 (GND), J102.12 (GND), J102.30 (GND); also elsewhere on the board
USB_CTL0: J101.34 (GPIO_27); also elsewhere on the board
USB_CTL1: J101.32 (GPIO_25); also elsewhere on the board
USB_CTL2: J101.28 (GPIO_23); also elsewhere on the board
USB_CTL3: J101.26 (GPIO_21); also elsewhere on the board
USB_CTL4: J101.24 (GPIO_19); also elsewhere on the board
USB_CTL5: J101.22 (GPIO_17); also elsewhere on the board
USB_CTL6: J101.20 (GPIO_15); also elsewhere on the board
USB_CTL7: J101.18 (GPIO_13); also elsewhere on the board
USB_CTL8: J101.16 (GPIO_11); also elsewhere on the board
USB_CTL9: J101.14 (GPIO_9); also elsewhere on the board
USB_CTL10: J101.10 (GPIO_7); also elsewhere on the board
USB_CTL11: J101.8 (GPIO_5); also elsewhere on the board
USB_CTL12: J101.6 (GPIO_3); also elsewhere on the board
USB_DATA0: J101.39 (GPIO_32); also elsewhere on the board
USB_DATA1: J101.37 (GPIO_30); also elsewhere on the board
USB_DATA2: J101.35 (GPIO_28); also elsewhere on the board
USB_DATA3: J101.33 (GPIO_26); also elsewhere on the board
USB_DATA4: J101.31 (GPIO_24); also elsewhere on the board
USB_DATA5: J101.27 (GPIO_22); also elsewhere on the board
USB_DATA6: J101.25 (GPIO_20); also elsewhere on the board
USB_DATA7: J101.23 (GPIO_18); also elsewhere on the board
USB_DATA8: J101.21 (GPIO_16); also elsewhere on the board
USB_DATA9: J101.19 (GPIO_14); also elsewhere on the board
USB_DATA10: J101.17 (GPIO_12); also elsewhere on the board
USB_DATA11: J101.15 (GPIO_10); also elsewhere on the board
USB_DATA12: J101.13 (GPIO_8); also elsewhere on the board
USB_DATA13: J101.9 (GPIO_6); also elsewhere on the board
USB_DATA14: J101.7 (GPIO_4); also elsewhere on the board
USB_DATA15: J101.5 (GPIO_2); also elsewhere on the board
USB_DATA16: J102.5 (GPIO_2); also elsewhere on the board
USB_DATA17: J102.6 (GPIO_3); also elsewhere on the board
USB_DATA18: J102.7 (GPIO_4); also elsewhere on the board
USB_DATA19: J102.8 (GPIO_5); also elsewhere on the board
USB_DATA20: J102.9 (GPIO_6); also elsewhere on the board
USB_DATA21: J102.10 (GPIO_7); also elsewhere on the board
USB_DATA22: J102.17 (GPIO_12); also elsewhere on the board
USB_DATA23: J102.18 (GPIO_13); also elsewhere on the board
USB_DATA24: J102.19 (GPIO_14); also elsewhere on the board
USB_DATA25: J102.20 (GPIO_15); also elsewhere on the board
USB_DATA26: J102.21 (GPIO_16); also elsewhere on the board
USB_DATA27: J102.22 (GPIO_17); also elsewhere on the board
USB_DATA28: J102.23 (GPIO_18); also elsewhere on the board
USB_DATA29: J102.24 (GPIO_19); also elsewhere on the board
USB_DATA30: J102.25 (GPIO_20); also elsewhere on the board
USB_DATA31: J102.26 (GPIO_21); also elsewhere on the board
USB_PCLK: J101.38 (GPIO_31); also elsewhere on the board

Notes on the sheet:
Note: All resistors 1% tolerance. All capacitors 10% tolerance. Unless otherwise noted

Parts:
J201: GPIFII_J7; PinHeader_2x20_P2.54mm_Vertical; LCSC Part C124383
J202: GPIFII_J6; PinHeader_2x20_P2.54mm_Vertical; LCSC Part C124383

Connections:
+5V: J202.3 (USB3_VBUS), J202.4 (USB3_VBUS); also elsewhere on the board
GND: J201.13 (GND), J201.15 (GND), J201.17 (GND), J201.25 (GND), J201.29 (GND), J201.39 (GND), J201.40 (GND), J202.6 (GND), J202.33 (GND), J202.37 (GND); also elsewhere on the board
USB_CTL0: J202.31 (CTL0); also elsewhere on the board
USB_CTL1: J202.29 (CTL1); also elsewhere on the board
USB_CTL2: J202.27 (CTL2); also elsewhere on the board
USB_CTL3: J202.25 (CTL3); also elsewhere on the board
USB_CTL4: J202.23 (CTL4_SW); also elsewhere on the board
USB_CTL5: J202.21 (CTL5); also elsewhere on the board
USB_CTL6: J202.19 (CTL6); also elsewhere on the board
USB_CTL7: J202.17 (CTL7); also elsewhere on the board
USB_CTL8: J202.15 (CTL8); also elsewhere on the board
USB_CTL9: J202.13 (CTL9); also elsewhere on the board
USB_CTL10: J202.11 (CTL10); also elsewhere on the board
USB_CTL11: J202.9 (CTL11); also elsewhere on the board
USB_CTL12: J202.7 (CTL12); also elsewhere on the board
USB_DATA0: J202.38 (DQ0); also elsewhere on the board
USB_DATA1: J202.36 (DQ1); also elsewhere on the board
USB_DATA2: J202.34 (DQ2); also elsewhere on the board
USB_DATA3: J202.32 (DQ3); also elsewhere on the board
USB_DATA4: J202.30 (DQ4); also elsewhere on the board
USB_DATA5: J202.28 (DQ5); also elsewhere on the board
USB_DATA6: J202.26 (DQ6); also elsewhere on the board
USB_DATA7: J202.24 (DQ7); also elsewhere on the board
USB_DATA8: J202.22 (DQ8); also elsewhere on the board
USB_DATA9: J202.20 (DQ9); also elsewhere on the board
USB_DATA10: J202.18 (DQ10); also elsewhere on the board
USB_DATA11: J202.16 (DQ11); also elsewhere on the board
USB_DATA12: J202.14 (DQ12); also elsewhere on the board
USB_DATA13: J202.12 (DQ13); also elsewhere on the board
USB_DATA14: J202.10 (DQ14); also elsewhere on the board
USB_DATA15: J202.8 (DQ15); also elsewhere on the board
USB_DATA16: J201.38 (DQ16); also elsewhere on the board
USB_DATA17: J201.36 (DQ17); also elsewhere on the board
USB_DATA18: J201.34 (DQ18); also elsewhere on the board
USB_DATA19: J201.32 (DQ19); also elsewhere on the board
USB_DATA20: J201.30 (DQ20); also elsewhere on the board
USB_DATA21: J201.28 (DQ21); also elsewhere on the board
USB_DATA22: J201.26 (DQ22); also elsewhere on the board
USB_DATA23: J201.24 (DQ23); also elsewhere on the board
USB_DATA24: J201.22 (DQ24); also elsewhere on the board
USB_DATA25: J201.20 (DQ25); also elsewhere on the board
USB_DATA26: J201.18 (DQ26); also elsewhere on the board
USB_DATA27: J201.16 (DQ27); also elsewhere on the board
USB_DATA28: J201.12 (DQ28); also elsewhere on the board
USB_DATA29: J201.10 (DQ29); also elsewhere on the board
USB_DATA30: J201.8 (DQ30); also elsewhere on the board
USB_DATA31: J201.6 (DQ31); also elsewhere on the board
USB_PCLK: J202.35 (PCLK); also elsewhere on the board

Notes on the sheet:
Power is supplied from the VBUS of the USB3 connection, so we flag the supply point here
Key pin

Parts:
C301, C303, C305, C307, C309, C311, C313, C314, C316, C317, C318: 100nF; C_0805; LCSC Part C49678
C302, C304, C306, C308, C310, C312, C315, C319: 2.2uF Tant; CP_Tantalum_Case-A_EIA-3216-18_Reflow; LCSC Part C7180
R301: 1K; R_0805; LCSC Part C17513
R302: 1K2; R_0805; LCSC Part C17379
U301: ADS825; SSOP-28_5.3x10.2mm_Pitch0.65mm; LCSC Part C1542665
U302, U303: 74LVTH541_PWR; TSSOP-20_4.4x6.5mm_Pitch0.65mm; LCSC Part C2876976

Connections:
+3.3VA: C316.1, C317.1, C318.1, C319.1, U301.28 (VDRV), U302.20 (VCC), U303.20 (VCC); also elsewhere on the board
+5VA: C313.1, C314.1, C315.1, U301.15 (+Vs), U301.17 (RSEL), U301.27 (+Vs); also elsewhere on the board
/ADC/IN: U301.25 (IN); also elsewhere on the board
/ADC/REFB: C309.1, C310.1, R302.1, U301.19 (REFB); also elsewhere on the board
/ADC/REFT: C307.1, C308.1, R301.2, U301.22 (REFT); also elsewhere on the board
ADC_CLK: U301.14 (CLK); also elsewhere on the board
ADC_DATA0: U302.18 (Y0); also elsewhere on the board
ADC_DATA1: U302.17 (Y1); also elsewhere on the board
ADC_DATA2: U302.16 (Y2); also elsewhere on the board
ADC_DATA3: U302.15 (Y3); also elsewhere on the board
ADC_DATA4: U302.14 (Y4); also elsewhere on the board
ADC_DATA5: U302.13 (Y5); also elsewhere on the board
ADC_DATA6: U302.12 (Y6); also elsewhere on the board
ADC_DATA7: U302.11 (Y7); also elsewhere on the board
ADC_DATA8: U303.18 (Y0); also elsewhere on the board
ADC_DATA9: U303.17 (Y1); also elsewhere on the board
GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, U301.1 (GND), U301.12 (~OE), U301.13 (PD), U301.16 (GND), U301.18 (~INT/EXT), U301.26 (GND), U302.1 (G1), U302.10 (GND), U302.19 (G2), U303.1 (G1), U303.4 (A2), U303.5 (A3), U303.6 (A4), U303.7 (A5), U303.8 (A6), U303.9 (A7), U303.10 (GND), U303.19 (G2); also elsewhere on the board
unnamed: U301.2 (Bit_1_(MSB)), U303.3 (A1)
unnamed: U301.3 (Bit_2), U303.2 (A0)
unnamed: U301.4 (Bit_3), U302.9 (A7)
unnamed: U301.5 (Bit_4), U302.8 (A6)
unnamed: U301.6 (Bit_5), U302.7 (A5)
unnamed: U301.7 (Bit_6), U302.6 (A4)
unnamed: U301.8 (Bit_7), U302.5 (A3)
unnamed: U301.9 (Bit_8), U302.4 (A2)
unnamed: U301.10 (Bit_9), U302.3 (A1)
unnamed: U301.11 (Bit_10_(LSB)), U302.2 (A0)
unnamed: C303.1, C304.1, U301.20 (ByB)
unnamed: C301.1, C302.1, U301.21 (ByT)
unnamed: C311.1, C312.1, U301.23 (CM)
unnamed: C305.1, C306.1, R301.1, R302.2, U301.24 (~IN)

Parts:
C401, C402, C408: 100nF; C_0805; LCSC Part C49678
C403: 330pF; C_0805; LCSC Part C107148
C404: 33pF; C_0805; LCSC Part C157687
C405: 470pF; C_0805; LCSC Part C1743
C406: 100pF; C_0805; LCSC Part C1790
C407: 270pF; C_0805; LCSC Part C113828
C409: 2.2uF Tant; CP_Tantalum_Case-A_EIA-3216-18_Reflow; LCSC Part C7180
J401: BNC_Rosenberger; BNC Socket; LCSC Part 51K204-400A5
L401: 680nH; L_0805; LCSC Part C139230
L402: 560nH; L_0805; LCSC Part C139229
R401: 56R; R_0805; LCSC Part C17757
R402, R403, R407: 1K; R_0805; LCSC Part C17513
R404: 100R; R_0805; LCSC Part C17408
R405: 200R; R_0805; LCSC Part C17540
R406: 1K5; R_0805; LCSC Part C4310
R408: 680R; R_0805; LCSC Part C17798
R409: 560R; R_0805; LCSC Part C28636
R410, R411: 47R; R_0805; LCSC Part C17714
SW401: Gain Select; SW_DIP_x4_W7.62mm_Slide_Copal_CHS-B; LCSC Part C3293144
U401: OPA690; SOIC-8_3.9x4.9mm_Pitch1.27mm; LCSC Part C1346889

Connections:
+5VA: C408.1, C409.1, U401.7 (+Vs), U401.8 (~DIS); also elsewhere on the board
/ADC/IN: R411.2; also elsewhere on the board
/ADC/REFB: R403.1; also elsewhere on the board
/ADC/REFT: R402.2; also elsewhere on the board
GND: C402.2, C403.2, C405.2, C407.2, C408.2, C409.2, J401.2 (GND), J401.3 (GND), J401.4 (GND), J401.5 (GND), R401.1, U401.4 (-Vs); also elsewhere on the board
unnamed: C401.1, R402.1, R403.2, R404.1
unnamed: C402.1, R405.1
unnamed: C403.1, C404.1, L401.2, R410.2
unnamed: C404.2, C405.1, C406.1, L401.1, L402.2
unnamed: C406.2, C407.1, L402.1, R411.1
unnamed: C401.2, J401.1 (Signal), R401.2
unnamed: R406.2, SW401.1
unnamed: R407.2, SW401.2
unnamed: R408.2, SW401.3
unnamed: R409.2, SW401.4
unnamed: R404.2, U401.3 (IN+)
unnamed: R405.2, R406.1, R407.1, R408.1, R409.1, U401.2 (IN-)
unnamed: R410.1, SW401.5, SW401.6, SW401.7, SW401.8, U401.6 (Output)

Notes on the sheet:
Note: The cable terminating resistor should take into account the parallel resistance of the dividing network: 1000 / 2 = 500 Ohms Rtotal = R1×R2/(R1+R2) (500 x 56) / (500 + 56) = 50.36 Ohms
2N Elliptic filter (14 MHz low-pass)
50 Ohm impedance RF input
Filter capacitor tolerance 5%

Parts:
C501, C503: 10uF TANT; CP_Tantalum_Case-B_EIA-3528-21_Reflow; LCSC Part C7193
C502, C504: 100nF; C_0805; LCSC Part C49678
L501: 100uH; Inductor_Bourns-SRU8043; LCSC Part C780190
U501: LM1117-3.3; SOT-223-3_TabPin2; LCSC Part C126027

Connections:
+3.3VA: C503.1, C504.1, U501.2 (VO); also elsewhere on the board
+5V: L501.2; also elsewhere on the board
+5VA: C501.1, C502.1, L501.1, U501.3 (VI); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, U501.1 (GND); also elsewhere on the board

Board: 2 copper layers, 95.2 x 57.2 mm, 59 parts (2 on the bottom side), 91 nets.

## KiCad design Hardware/DomesdayDuplicator-base-DE0Nano/DomesdayDuplicator-base-DE0Nano.kicad_pcb

Parts:
J201: GPIO-0; PinSocket_2x20_P2.54mm_Vertical
J202: GPIO-1; PinSocket_2x20_P2.54mm_Vertical
J203: GPIO-2; IDC-Header_2x13_P2.54mm_Horizontal

Connections:
+5V: J201.11 (VCC_SYS), J202.11 (VCC_SYS); also elsewhere on the board
/Cypress FX3/USB_CTL0: J203.17 (GPIO-2-12); also elsewhere on the board
/Cypress FX3/USB_CTL1: J203.16 (GPIO-2-11); also elsewhere on the board
/Cypress FX3/USB_CTL2: J203.15 (GPIO-2-10); also elsewhere on the board
/Cypress FX3/USB_CTL3: J203.14 (GPIO-2-9); also elsewhere on the board
/Cypress FX3/USB_CTL4: J203.13 (GPIO-2-8); also elsewhere on the board
/Cypress FX3/USB_CTL5: J203.12 (GPIO-2-7); also elsewhere on the board
/Cypress FX3/USB_CTL6: J203.11 (GPIO-2-6); also elsewhere on the board
/Cypress FX3/USB_CTL7: J203.10 (GPIO-2-5); also elsewhere on the board
/Cypress FX3/USB_CTL8: J203.9 (GPIO-2-4); also elsewhere on the board
/Cypress FX3/USB_CTL9: J203.8 (GPIO-2-3); also elsewhere on the board
/Cypress FX3/USB_CTL10: J203.7 (GPIO-2-2); also elsewhere on the board
/Cypress FX3/USB_CTL11: J203.6 (GPIO-2-1); also elsewhere on the board
/Cypress FX3/USB_CTL12: J203.5 (GPIO-2-0); also elsewhere on the board
/Cypress FX3/USB_DATA0: J202.5 (GPIO_1_2); also elsewhere on the board
/Cypress FX3/USB_DATA1: J202.6 (GPIO_1_3); also elsewhere on the board
/Cypress FX3/USB_DATA2: J202.7 (GPIO_1_4); also elsewhere on the board
/Cypress FX3/USB_DATA3: J202.9 (GPIO_1_6); also elsewhere on the board
/Cypress FX3/USB_DATA4: J202.13 (GPIO_1_8); also elsewhere on the board
/Cypress FX3/USB_DATA5: J202.15 (GPIO_1_10); also elsewhere on the board
/Cypress FX3/USB_DATA6: J202.17 (GPIO_1_12); also elsewhere on the board
/Cypress FX3/USB_DATA7: J202.19 (GPIO_1_14); also elsewhere on the board
/Cypress FX3/USB_DATA8: J202.21 (GPIO_1_16); also elsewhere on the board
/Cypress FX3/USB_DATA9: J202.23 (GPIO_1_18); also elsewhere on the board
/Cypress FX3/USB_DATA10: J202.25 (GPIO_1_20); also elsewhere on the board
/Cypress FX3/USB_DATA11: J202.27 (GPIO_1_22); also elsewhere on the board
/Cypress FX3/USB_DATA12: J202.31 (GPIO_1_24); also elsewhere on the board
/Cypress FX3/USB_DATA13: J202.33 (GPIO_1_26); also elsewhere on the board
/Cypress FX3/USB_DATA14: J202.35 (GPIO_1_28); also elsewhere on the board
/Cypress FX3/USB_DATA15: J202.37 (GPIO_1_30); also elsewhere on the board
/Cypress FX3/USB_DATA16: J202.2 (GPIO_1_0); also elsewhere on the board
/Cypress FX3/USB_DATA17: J202.4 (GPIO_1_1); also elsewhere on the board
/Cypress FX3/USB_DATA18: J202.10 (GPIO_1_7); also elsewhere on the board
/Cypress FX3/USB_DATA19: J202.14 (GPIO_1_9); also elsewhere on the board
/Cypress FX3/USB_DATA20: J202.16 (GPIO_1_11); also elsewhere on the board
/Cypress FX3/USB_DATA21: J202.18 (GPIO_1_13); also elsewhere on the board
/Cypress FX3/USB_DATA22: J202.20 (GPIO_1_15); also elsewhere on the board
/Cypress FX3/USB_DATA23: J202.22 (GPIO_1_17); also elsewhere on the board
/Cypress FX3/USB_DATA24: J202.24 (GPIO_1_19); also elsewhere on the board
/Cypress FX3/USB_DATA25: J202.26 (GPIO_1_21); also elsewhere on the board
/Cypress FX3/USB_DATA26: J202.28 (GPIO_1_23); also elsewhere on the board
/Cypress FX3/USB_DATA27: J202.32 (GPIO_1_25); also elsewhere on the board
/Cypress FX3/USB_DATA28: J202.34 (GPIO_1_27); also elsewhere on the board
/Cypress FX3/USB_DATA29: J202.36 (GPIO_1_29); also elsewhere on the board
/Cypress FX3/USB_DATA30: J202.38 (GPIO_1_31); also elsewhere on the board
/Cypress FX3/USB_DATA31: J202.40 (GPIO_1_33); also elsewhere on the board
/Cypress FX3/USB_PCLK: J202.8 (GPIO_1_5); also elsewhere on the board
/DE0-Nano/MOD0_CLK: J201.22 (GPIO_0_17); also elsewhere on the board
/DE0-Nano/MOD0_D0: J201.40 (GPIO_0_33); also elsewhere on the board
/DE0-Nano/MOD0_D1: J201.39 (GPIO_0_32); also elsewhere on the board
/DE0-Nano/MOD0_D2: J201.38 (GPIO_0_31); also elsewhere on the board
/DE0-Nano/MOD0_D3: J201.37 (GPIO_0_30); also elsewhere on the board
/DE0-Nano/MOD0_D4: J201.36 (GPIO_0_29); also elsewhere on the board
/DE0-Nano/MOD0_D5: J201.35 (GPIO_0_28); also elsewhere on the board
/DE0-Nano/MOD0_D6: J201.34 (GPIO_0_27); also elsewhere on the board
/DE0-Nano/MOD0_D7: J201.33 (GPIO_0_26); also elsewhere on the board
/DE0-Nano/MOD0_D8: J201.32 (GPIO_0_25); also elsewhere on the board
/DE0-Nano/MOD0_D9: J201.31 (GPIO_0_24); also elsewhere on the board
/DE0-Nano/MOD0_D10: J201.28 (GPIO_0_23); also elsewhere on the board
/DE0-Nano/MOD0_D11: J201.27 (GPIO_0_22); also elsewhere on the board
/DE0-Nano/MOD0_D12: J201.26 (GPIO_0_21); also elsewhere on the board
/DE0-Nano/MOD0_D13: J201.25 (GPIO_0_20); also elsewhere on the board
/DE0-Nano/MOD0_D14: J201.24 (GPIO_0_19); also elsewhere on the board
/DE0-Nano/MOD0_D15: J201.23 (GPIO_0_18); also elsewhere on the board
/DE0-Nano/MOD1_CLK: J201.2 (GPIO_0_0); also elsewhere on the board
/DE0-Nano/MOD1_D0: J201.21 (GPIO_0_16); also elsewhere on the board
/DE0-Nano/MOD1_D1: J201.20 (GPIO_0_15); also elsewhere on the board
/DE0-Nano/MOD1_D2: J201.19 (GPIO_0_14); also elsewhere on the board
/DE0-Nano/MOD1_D3: J201.18 (GPIO_0_13); also elsewhere on the board
/DE0-Nano/MOD1_D4: J201.17 (GPIO_0_12); also elsewhere on the board
/DE0-Nano/MOD1_D5: J201.16 (GPIO_0_11); also elsewhere on the board
/DE0-Nano/MOD1_D6: J201.15 (GPIO_0_10); also elsewhere on the board
/DE0-Nano/MOD1_D7: J201.14 (GPIO_0_9); also elsewhere on the board
/DE0-Nano/MOD1_D8: J201.13 (GPIO_0_8); also elsewhere on the board
/DE0-Nano/MOD1_D9: J201.10 (GPIO_0_7); also elsewhere on the board
/DE0-Nano/MOD1_D10: J201.9 (GPIO_0_6); also elsewhere on the board
/DE0-Nano/MOD1_D11: J201.8 (GPIO_0_5); also elsewhere on the board
/DE0-Nano/MOD1_D12: J201.7 (GPIO_0_4); also elsewhere on the board
/DE0-Nano/MOD1_D13: J201.6 (GPIO_0_3); also elsewhere on the board
/DE0-Nano/MOD1_D14: J201.5 (GPIO_0_2); also elsewhere on the board
/DE0-Nano/MOD1_D15: J201.4 (GPIO_0_1); also elsewhere on the board
GND: J201.12 (GND), J201.30 (GND), J202.12 (GND), J202.30 (GND), J203.26 (GND); also elsewhere on the board

Notes on the sheet:
0 to 15 on this side
16-30 on this side

Notices in the files:
Hardware/DomesdayDuplicator-base-DE0Nano/DomesdayDuplicator-base-DE0Nano.kicad_pcb:
(C) 2019 Simon Inns - Attribution ShareAlike 4.0 International (CC BY-SA 4.0)
KiCAD/Domesday Duplicator/Domesday Duplicator.kicad_pcb:
(c)2018 Simon Inns
License: Attribution-ShareAlike 4.0 International (CC BY-SA 4.0)
