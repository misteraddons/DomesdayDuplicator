# Repository misteraddons/DomesdayDuplicator (continued)

## KiCad design Hardware/DomesdayDuplicator-module-ADS825/DomesdayDuplicator-module-ADS825.kicad_pcb (continued)

Parts:
J601: Module_Connector; PinSocket_2x10_P2.54mm_Vertical

Connections:
+3V3: J601.19; also elsewhere on the board
+5VA: J601.18; also elsewhere on the board
/ADC/CLK: J601.17; also elsewhere on the board
/Header/DB0: J601.1; also elsewhere on the board
/Header/DB1: J601.2; also elsewhere on the board
/Header/DB2: J601.3; also elsewhere on the board
/Header/DB3: J601.4; also elsewhere on the board
/Header/DB4: J601.5; also elsewhere on the board
/Header/DB5: J601.6; also elsewhere on the board
/Header/DB6: J601.7; also elsewhere on the board
/Header/DB7: J601.8; also elsewhere on the board
/Header/DB8: J601.9; also elsewhere on the board
/Header/DB9: J601.10; also elsewhere on the board
/Header/DB10: J601.11; also elsewhere on the board
GND: J601.20; also elsewhere on the board

Parts:
FID701, FID702, FID703: Fiducial; Fiducial_0.5mm_Dia_1mm_Outer
H701: MountingHole; MountingHole_2.2mm_M2

Board: 2 copper layers, 49.5 x 38.1 mm, 60 parts (1 on the bottom side), 51 nets.

## Commit log (part)

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2019-09-01 Reorganisation of repository
2019-09-02 Draft schematic for ADS825E module
2019-09-02 Added DdD base DE0-Nano connections and part mapping for ADS825 module
2019-09-02 Additional schematics for the base-board design + FX3 header parts
2019-09-03 Fixes to module and base - added component mapping to base and verified mirrored headers
2019-09-04 Added protection resistors to module headers on the base-board
2019-09-11 Work on the ADS825 module to determine the overall module dimensions and mounting
2019-09-15 Mechanical set up of base board and basic routing
2019-09-15 Finished base board ready for review
2019-09-15 Added ld-decode logo
2019-09-16 Added ADC module complete with routing
2025-09-22 Update to KiCad 9 and JLCPCB parts
